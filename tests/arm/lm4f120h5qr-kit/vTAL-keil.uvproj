# Keil uVision project vTAL-keil.uvproj, settings and files
target vTAL-Test (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: vTAL-keil
  AfterMake: fromelf --bin --output .\rvmdk\vTAL-keil.bin .\rvmdk\vTAL-keil.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk
  c include: ../../../vTAL/;../../../vTAL/vTAL-src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: Startup.s VTAL_stellaris_Test.c
  group vTAL
    ../../../vTAL/vTAL-src/: vTAL.c
    ../../../vTAL/vTAL-src/arch/arm/stellaris-ek-lm4f120xl/: WTimerA0.c
